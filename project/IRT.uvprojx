# Keil uVision project IRT.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x0B0000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BOOT_HQ
  BeforeMake: git clean -dfx ../output/bootloader_vet6
  BeforeMake: $P..\tools\format_all.bat
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=../output/bootloader_vet6/@L.bin !L
  AfterMake: $P..\tools\after_build.bat ../output/bootloader_vet6
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F470
  c include: ..\src\freertos\include;..\src\freertos\portable\RVDS\ARM_CM4F;..\src;..\src\app;..\src\app\arch;..\src\app\comm;..\src\app\sys;..\src\bsp\dev;..\src\bsp\periph;..\src\lib\microlib;..\src\lib\fwlib;..\src\lib\cmsis\gd32;..\src\lib\fs;..\src\lib\usb;..\src\lib\lwip\include;..\src\lib\lwip;..\src\utils\systemview;..\src\utils\cm_backtrace;..\src\utils\cm_backtrace\Languages\en-US;..\src\utils\cm_backtrace\Languages\zh-CN;..\src\app\para;..\src\app\proto;..\src\app\record;..\src\app\ui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xb0000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\BOOT_HQ.sct
  group app
    ../src/app/: boot_main.c app_main.c app_cfg.h platform.h tools_cfg.h
  group app/comm
    ../src/app/comm/: pc.c pc.h tcp_server.c tcp_server.h comm_cfg.c comm_cfg.h
  group app/arch
    ../src/app/arch/: agent.c agent.h mail_box.c mail_box.h message.c message.h ostimer.c ostimer.h serial.c serial.h storage.c storage.h thread.c thread.h arch_cfg.h
  group app/sys
    ../src/app/sys/: sys_cfg.h console.c console.h system.c system.h upgrade.c upgrade.h camera.c camera.h measure.c measure.h tiag.c tiag.h analogout.c analogout.h alarm.c alarm.h burst.c burst.h heater.c heater.h self_check.c
  group app/para
    ../src/app/para/: para.c para.h para_cfg.c para_cfg.h
  group app/proto
    ../src/app/proto/: proto_char.c proto_char.h proto_char_cfg.c proto_char_cfg.h proto_base.c proto_base.h proto_base_cfg.c proto_base_cfg.h proto_coef.c proto_coef.h
  group app/record
    ../src/app/record/: record.c record.h record_cfg.c record_cfg.h
  group app/ui
    ../src/app/ui/: ui.c ui.h display.c display.h key.c key.h
  group bsp/dev
    ../src/bsp/dev/: soft_i2c.c soft_i2c.h ltc2606.c ltc2606.h tm1639.c tm1639.h vti7064x.c vti7064x.h ds18b20.c ds18b20.h eeprom.c eeprom.h ad7124.c ad7124.h ov5640.c ov5640.h ov5640_cfg.h oled.c oled.h oledfont.h ntc_cfg.h tiag_cfg.h
  group bsp/periph
    ../src/bsp/periph/: gd32_ll.c gd32_ll.h gd32_adc.c gd32_adc.h gd32_rtc.c gd32_rtc.h gd32_spi.c gd32_spi.h gd32_timer.c gd32_timer.h gd32_dma.c gd32_dma.h gd32_fmc.c gd32_fmc.h gd32_uart.c gd32_uart.h gd32_eth.c gd32_eth.h gd32_exmc.c gd32_exmc.h gd32_crc.c gd32_crc.h gd32_exti.c gd32_exti.h gd32_dci.c gd32_dci.h
  group lib/microlib
    ../src/lib/microlib/: hq_cdllist.c hq_cdllist.h hq_filter.c hq_filter.h hq_generic.c hq_generic.h hq_io.c hq_io.h hq_string.c hq_string.h hq_hash.c hq_hash.h lib_cfg.h
  group lib/fwlib
    ../src/lib/fwlib/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group lib/cmsis
    ../src/lib/cmsis/gd32/: system_gd32f4xx.c startup_gd32f450_470.s
  group lwip
    ../src/lwip/: lwip.c lwip.h lwipopts.h
  group lwip/netif
    ../src/lwip/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group lwip/core
    ../src/lwip/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../src/lwip/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/arch
    ../src/lwip/arch/: ethernetif.c sys_arch.c
  group lwip/api
    ../src/lwip/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group freertos
    ../src/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../src/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../src/freertos/portable/MemMang/: heap_4.c
    ../src/freertos/include/: FreeRTOSConfig.h
  group utils/systemview
    ../src/utils/systemview/: Global.h SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.h SEGGER_SYSVIEW_Int.h
  group utils/cm_backtrace
    ../src/utils/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../src/utils/cm_backtrace/Languages/zh-CN/: cmb_zh_CN.h cmb_zh_CN_UTF8.h
    ../src/utils/cm_backtrace/Languages/en-US/: cmb_en_US.h
    ../src/utils/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group usb/usb_driver
    ../src/usb/driver/Source/: drv_usbh_int.c drv_usb_core.c drv_usb_host.c
  group usb/usb_host
    ../src/usb/host/core/Source/: usbh_transc.c usbh_core.c usbh_enum.c usbh_pipe.c
  group usb/usb_class
    ../src/usb/host/class/video/Src/: usbh_video_stream_parsing.c usbh_video.c usbh_video_desc_parsing.c
  group usb/usb_user
    ../src/usb/user/Src/: usbh_usr.c gd32f4xx_usb_hw.c
target app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: as above
  output: APP
  BeforeMake: git clean -dfx ../output/app_vet6
  BeforeMake: $P..\tools\format_all.bat
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=../output/app_vet6/@L.bin !L
  AfterMake: $P..\tools\after_build.bat ../output/bootloader_vet6 ../output/app_vet6  IRT_release
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F470,USE_USB_FS
  c include: ..\src\freertos\include;..\src\freertos\portable\RVDS\ARM_CM4F;..\src;..\src\app;..\src\app\arch;..\src\app\comm;..\src\app\para;..\src\app\proto;..\src\app\record;..\src\app\sys;..\src\app\ui;..\src\bsp\dev;..\src\bsp\periph;..\src\lib\cmsis\gd32;..\src\lib\microlib;..\src\lib\fwlib;..\src\lib\fs;..\src\lib\usb;..\src\lwip;..\src\lwip\include;..\src\utils\systemview;..\src\utils\cm_backtrace;..\src\utils\cm_backtrace\Languages\en-US;..\src\utils\cm_backtrace\Languages\zh-CN;..\src\lwip\netif;..\src\usb\driver\Include;..\src\usb\host\core\Include;..\src\usb\host\class\video\Inc;..\src\usb\user\Inc;..\src\usb\ustd\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xb0000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\APP.sct
software components: CMSIS:CORE 5.6.0, Utilities:perf_counter:Core 2.4.0
